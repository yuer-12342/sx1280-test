# Keil uVision project sx1280_ranging.uvprojx, settings and files
target template_Release (6160000::V6.16::ARMCLANG)
  device: HC32L021C8PB HDSC
  pack: HDSC.HC32L02x.1.1.0
  cpu: IRAM(0x20000000,0x1800) IROM(0x00000000,0x10000) CPUTYPE("Cortex-M0+") CLOCK(12000000) ELITTLE
  output: template +hex
  c flags: Optim=7 OneElfS=1 uC99=1 v6Lang=5 wLevel=4
  c include: ..\..\mcu\common;..\..\driver\inc;..\source;..\..\sx1280\driver;..\..\sx1280\driver\rangingCorrection;..\..\sx1280\hal\hc32;..\..\sx1280\app;..\..\sx1280\app\ranging;..\..\sx1280\app\lcd
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x1800
  link misc: --keep=*Handler
  group common
    ./: startup_hc32l021.s
    ../../mcu/common/: system_hc32l021.c interrupts_hc32l021.c board_stkhc32l021.c
  group hc32-ddl
    ../../driver/src/: ddl.c sysctrl.c gpio.c spi.c flash.c atim3.c
  group README
    ../: Readme.txt
  group sx1280-driver
    ../../sx1280/driver/: sx1280.c sx1280.h radio.h RangingCorrection.h utilities.c rangingCorrection_tables.c utilities.h
  group sx1280-hal
    ../../sx1280/hal/hc32/: hw.h hw.c hw-lptim.c sx1280-hal.h sx1280_hal_hc32.c sx1280_hal_hc32.h radio.c time_hc32.c timer_hc32.h board_antenna.c board_hc32l021.h sx1280_irq_hc32.c spi_mutex.c shared_spi_bus.c board_ui.c
  group sx1280-display
    ../../sx1280/app/lcd/: lcd.c lcd_init.c ranging_display.c
  group sx1280-ranging
    ../../sx1280/app/ranging/: demoRanging.c demoRanging.h ranging_fence.c ranging_fence.h ranging_publish.c ranging_publish.h ranging_dev_log.c ranging_dev_log.h fence_alarm.c fence_alarm.h FreqLUT.h
  group rangingCorrection
    ../../sx1280/driver/rangingCorrection/: rangingCorrection_defines.h rangingCorrectionSF5BW0400.h rangingCorrectionSF5BW0800.h rangingCorrectionSF5BW1600.h rangingCorrectionSF6BW0400.h rangingCorrectionSF6BW0800.h rangingCorrectionSF6BW1600.h rangingCorrectionSF7BW0400.h rangingCorrectionSF7BW0800.h rangingCorrectionSF7BW1600.h rangingCorrectionSF8BW0400.h rangingCorrectionSF8BW0800.h rangingCorrectionSF8BW1600.h rangingCorrectionSF9BW0400.h rangingCorrectionSF9BW0800.h rangingCorrectionSF9BW1600.h rangingCorrectionSF10BW0400.h rangingCorrectionSF10BW0800.h rangingCorrectionSF10BW1600.h
  group sx1280-main
    ../../sx1280/app/: main.c
software components: CMSIS:CORE 5.2.0
